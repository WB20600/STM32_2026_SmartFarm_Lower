# Keil uVision project SJRobot_center.uvprojx, settings and files
target SJRobot_center (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SJRobot_center +hex
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\CORE;..\Drive_include;..\DSP_LIB\Include;..\FWLIB\inc;..\Hardware_include;..\User_include;..\Framework
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../CORE/: stm32f4xx_it.c system_stm32f4xx.c startup_stm32f40_41xxx.s
  group DSP_LIB
    ../DSP_LIB/: arm_cortexM4lf_math.lib
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c
  group Drive_program
    ../Drive_program/: GPIO_int.c Sys.c uart1.c
  group Hardware_program
    ../Hardware_program/: y_beep.c y_motor.c
  group Framework
    ../Framework/: main.c motion.c protocol.c scheduler.c uart6_link.c actuator.c
